# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 12864.c delay.c pwm.c serial.c sht11.c pid.c motor.c
